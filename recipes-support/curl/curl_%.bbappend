# SFTP and SCP client support in curl and libcurl (sftp:// and scp:// URLs), for uploads from the
# device.
PACKAGECONFIG_append_class-target = " libssh2"
